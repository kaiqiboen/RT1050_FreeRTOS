# Keil uVision project RT1050.uvprojx, settings and files
target Target_norflash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT1050 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, SERIAL_PORT_TYPE_UART=1
  c misc: --library_interface=armcc  --library_type=standardlib  --diag_suppress=66,1296,186
  c include: ..\Source\Devices\CMSIS\Include;..\Source\Devices\MIMXRT1052\arm;..\Source\Devices\MIMXRT1052\drivers;..\Source\Devices\MIMXRT1052\utilities\debug_console;..\Source\Devices\MIMXRT1052\utilities\str;..\Source\Devices\MIMXRT1052\xip;..\Source\Devices\MIMXRT1052\cmsis_drivers;..\Source\UserApp\Main;..\Source\UserApp\BSP;..\Source\Devices\Component\serial_manager;..\Source\Devices\Component\lists;..\Source\Devices\Component\uart;..\Source\Config;..\Source\OS\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\Source\OS\FreeRTOS\include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group CMSIS
    ../Source/Devices/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
  group startup
    ../Source/Devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group utilities
    ../Source/Devices/MIMXRT1052/utilities/: fsl_assert.c fsl_notifier.c
    ../Source/Devices/MIMXRT1052/utilities/str/: fsl_str.c
    ../Source/Devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c
  group board
    ../Source/UserApp/Main/: board.c clock_config.c pin_mux.c
  group xip
    ../Source/Devices/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group driver
    ../Source/Devices/MIMXRT1052/drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c
  group user
    ../Source/UserApp/Main/: gpio_led_output.c
    ../Source/UserApp/BSP/key/: bsp_key.c
  group component-serial_manager
    ../Source/Devices/Component/serial_manager/: serial_manager.c serial_port_uart.c
  group component-lists
    ../Source/Devices/Component/lists/: generic_list.c
  group component-uart
    ../Source/Devices/Component/uart/: lpuart_adapter.c
  group device
    ../Source/Devices/MIMXRT1052/: system_MIMXRT1052.c
  group FreeRTOS_src
    ../Source/OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ../Source/OS/FreeRTOS/portable/MemMang/: heap_4.c
    ../Source/OS/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Config
    ../Source/Config/: FreeRTOSConfig.h
target Target_sram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: RT1050.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1052DVL6B, SERIAL_PORT_TYPE_UART=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\Source\Devices\CMSIS\Include;..\Source\Devices\MIMXRT1052\arm;..\Source\Devices\MIMXRT1052\drivers;..\Source\Devices\MIMXRT1052\utilities\debug_console;..\Source\Devices\MIMXRT1052\utilities\str;..\Source\Devices\MIMXRT1052\xip;..\Source\Devices\MIMXRT1052\cmsis_drivers;..\Source\UserApp\Main;..\Source\UserApp\BSP;..\Source\Devices\Component\serial_manager;..\Source\Devices\Component\lists;..\Source\Devices\Component\uart;..\Source\Config;..\Source\OS\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\Source\OS\FreeRTOS\include;..\Source\UserApp\BSP\key
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\Source\Devices\MIMXRT1052\arm\MIMXRT1052xxxxx_sdram.scf
  link misc: --remove
